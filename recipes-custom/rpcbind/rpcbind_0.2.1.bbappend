UCLIBCPATCHES_libc-uclibc = "file://0002-uclibc-rpcsvc-defines.patch"
