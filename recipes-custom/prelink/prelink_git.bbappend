# the latest prelink version results in a kernel oops for coolstream-hd2 glibc images
# SRCREV = "40327fb99654e96db6ef15e2f2d5ef140ac3e998"

