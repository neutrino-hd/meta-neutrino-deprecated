FILESEXTRAPATHS_prepend := "${THISDIR}/procps-3.2.8:"

SRC_URI += "file://sysctl.conf"

