#disable ptest because off building problems with uclibc

inherit autotools texinfo update-alternatives gettext

