DEPENDS_libc-uclibc = "libiconv"
LDFLAGS_libc-uclibc += "-liconv"
