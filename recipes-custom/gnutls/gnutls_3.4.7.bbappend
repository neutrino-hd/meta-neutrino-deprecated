DEPENDS_append_libc-uclibc += "argp-standalone"

LDFLAGS_append_libc-uclibc += "-largp "
