FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI_append += "file://fix_build_without_SYS_getrandom.patch \
"


