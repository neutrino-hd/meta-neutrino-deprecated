PACKAGECONFIG ??= "curl"

