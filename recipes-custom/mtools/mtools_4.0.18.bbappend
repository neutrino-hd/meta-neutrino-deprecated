RDEPENDS_${PN} = ""
RRECOMMENDS_${PN} = ""
