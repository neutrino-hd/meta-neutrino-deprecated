FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://build_fix.patch \
"
