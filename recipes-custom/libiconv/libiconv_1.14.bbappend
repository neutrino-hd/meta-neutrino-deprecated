
do_install_append () {
	rm -rf ${D}${libdir}/libiconv.a
}

