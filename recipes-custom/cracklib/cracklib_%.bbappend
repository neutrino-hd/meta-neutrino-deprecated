DEPENDS_libc-uclibc = "cracklib-native zlib python gettext"
