FILESEXTRAPATHS_prepend := "${THISDIR}/libtirpc:"

SRC_URI += "file://remove-des-uclibc.patch"
