CFLAGS_append += "-Wno-maybe-uninitialized"
