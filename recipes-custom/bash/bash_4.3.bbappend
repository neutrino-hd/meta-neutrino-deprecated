RDEPENDS_${PN}_libc-uclibc += "base-files libiconv"
