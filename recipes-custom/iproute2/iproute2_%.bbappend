DEPENDS_libc-uclibc = "flex-native bison-native iptables"
