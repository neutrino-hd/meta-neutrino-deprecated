
DEPENDS_coolstream-hd2 = "zlib"

