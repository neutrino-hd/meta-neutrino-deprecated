DEPENDS_coolstream = "zlib openssl"
CURLGNUTLS_coolstream = "--with-gnutls --with-ssl"
