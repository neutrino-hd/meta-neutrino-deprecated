
DEPENDS_coolstream = "zlib"

